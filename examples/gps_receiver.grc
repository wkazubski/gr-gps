options:
  parameters:
    author: Samu Laaja
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: GPS receiver
  states: {}

blocks:
- name: bpsk_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: code_sel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '32'
    value: '10'
  states: {}
- name: lnagain
  id: variable_qtgui_range
  parameters:
    label: LNA Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '6'
    value: '6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1023e3 * 2
  states: {}
- name: vga1gain
  id: variable_qtgui_range
  parameters:
    label: VGA1 Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '5'
    step: '1'
    stop: '30'
    value: '30'
  states: {}
- name: vga2gain
  id: variable_qtgui_range
  parameters:
    label: VGA2 Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '30'
    value: '30'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '512'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk_constellation
    fmax: '1'
    fmin: '-1'
    loop_bw: 6.28/100
    showports: 'True'
  states: {}
- name: gps_gps_despread_0
  id: gps_gps_despread
  parameters:
    code_sel: code_sel
    osr_sel: '2'
  states: {}
- name: gps_gps_navdata_0
  id: gps_gps_navdata
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,fpga=/home/samu/hostedx40.rbf
    bb_gain0: vga2gain
    bw0: 2e6
    freq0: 1575.420e6
    gain0: lnagain
    gain_mode0: 'False'
    if_gain0: vga1gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [dc_blocker_xx_0, '0', gps_gps_despread_0, '0']
- [digital_constellation_receiver_cb_0, '0', gps_gps_navdata_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '4', blocks_null_sink_0_0_0_0_0, '0']
- [gps_gps_despread_0, '0', digital_constellation_receiver_cb_0, '0']
- [gps_gps_despread_0, '0', qtgui_time_sink_x_0, '0']
- [gps_gps_navdata_0, '0', blocks_null_sink_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
