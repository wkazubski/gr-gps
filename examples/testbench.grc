options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: noiselevel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '100e-3'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2000e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noiselevel
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-7700'
    offset: '0'
    phase: '0'
    samp_rate: 1023e3 * 4
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 10 * 4
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gps_gps_codegen_c_0
  id: gps_gps_codegen_c
  parameters:
    code: '5'
    datamode: '1'
    samplerate: 1023e3 * 4
  states: {}
- name: gps_gps_despread_0
  id: gps_gps_despread
  parameters:
    code_sel: '5'
    osr_sel: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT Plot"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Scope Plot"'
    size: '1024'
    srate: samp_rate
    type: complex
    yunit: '"Counts"'
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_throttle_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_skiphead_0, '0', gps_gps_despread_0, '0']
- [blocks_throttle_0, '0', blocks_skiphead_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [gps_gps_codegen_c_0, '0', blocks_multiply_xx_0_0, '0']
- [gps_gps_despread_0, '0', blocks_null_sink_0, '0']
- [gps_gps_despread_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
